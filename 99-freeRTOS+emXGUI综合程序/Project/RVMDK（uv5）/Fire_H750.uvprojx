# Keil uVision project Fire_H750.uvprojx, settings and files
target Fire_emxgui (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_emxgui
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,X_GUI_USE_FREERTOS,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User;..\..\User\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\User\bsp\cm_backtrace;..\..\emXGUI_Lib\inc;..\..\emXGUI_Lib\drv;..\..\emXGUI_Lib\arch\Inc;..\..\emXGUI_Lib\app\base;..\..\User\bsp\FATFS;..\..\emXGUI_Lib\app\base\res_writer;..\..\emXGUI_Lib\app\tutorial\rgb_led;..\..\User\OwnerDraw;..\..\emXGUI_Lib\app\tutorial\music_player;..\..\User\bsp\mp3\real;..\..\User\bsp\mp3\pub;..\..\emXGUI_Lib\app\tutorial\pic_view;..\..\emXGUI_Lib\app\tutorial\camera
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group USER
    ../../User/: main.c stm32h7xx_it.c board.h FreeRTOSConfig.h cpuusage.c
    ../../User/OwnerDraw/: Widget.c
  group BSP
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/usart/: bsp_usart.c
    ../../User/bsp/sdram/: bsp_sdram.c
    ../../User/bsp/flash/: bsp_qspi_flash.c
    ../../User/bsp/lcd/: bsp_lcd.c
    ../../User/bsp/delay/: core_delay.c
    ../../User/bsp/touch/: bsp_i2c_touch.c bsp_touch_gtxx.c
    ../../User/bsp/sd_card/: bsp_sdio_sd.c
    ../../User/bsp/tim/: bsp_basic_tim.c
    ../../User/bsp/dma2d/: dma2d_emxgui.c
    ../../User/bsp/wm8978/: bsp_wm8978.c
    ../../User/bsp/i2c/: i2c.c
    ../../User/bsp/mp3Player/: mp3Player.c
    ../../User/bsp/sai/: bsp_sai.c
    ../../User/bsp/mpu/: bsp_mpu.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM7/r0p1/: port.c
  group cm_backtrace
    ../../User/bsp/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../../User/bsp/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group emxgui/arch
    ../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c
    ../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../../emXGUI_Lib/arch/Inc/: gui_drv.h gui_os_port.h
  group emxgui/resource
    ../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
    ../../emXGUI_Lib/resource/pic/: blue_fish_bitmap.c crocodile_bitmap.c red_fish_bitmap.c gui_demo_pic_jpeg.c
  group emxgui/drv
    ../../User/: gui_drv_cfg.h
    ../../emXGUI_Lib/drv/: gui_font_port.c gui_fs_port.c gui_input_port.c gui_lcd_port.c gui_log_port.c gui_mem_port.c gui_resource_port.c gui_startup.c gui_touch_port.c gui_picture_port.c
  group emxgui/inc
    ../../emXGUI_Lib/inc/: def.h emXGUI.h emXGUI_Arch.h GUI_Font_XFT.h Web_Color.h x_libc.h x_obj.h Clist.h emXGUI_JPEG.h
  group emxgui/libs
    ../../emXGUI_Lib/libs/: x_libc_MDK_M7.lib libpng_MDK_M7.lib x_obj.cpp libjpeg_MDK_M4.lib libjpeg_MDK_M7.lib emXGUI100_MDK_M7.lib emXGUI100_MDK_M4.lib
  group base_app
    ../../emXGUI_Lib/app/base/: gui_desktop.c CListMenu.cpp CListMenu.h GUI_AppDef.h GUI_DEMO_Window.c
    ../../emXGUI_Lib/app/base/res_writer/: backend_res_writer.c GUI_RES_Writer_Dialog.c
    ../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../emXGUI_Lib/app/demo/: GUI_DEMO_SlideWindow.c GUI_Board_App_Desktop.c GUI_App_Desktop.c GUI_DEMO_Graphics_Accelerator.c GUI_DEMO_ShowWave.cpp
  group emxgui/res
    ../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
  group DOC
    ../../: 必读说明.txt
  group Fafts
    ../../User/bsp/FATFS/: diskio.c ff.c ffconf.h ff_gen_drv.c
    ../../User/bsp/FATFS/option/: cc936.c syscall.c
    ../../User/bsp/FATFS/drivers/: sd_diskio_dma.c fatfs_sd_sdio.c
  group tutorial/rgb_led
    ../../User/bsp/mp3/real/: buffers.c
    ../../emXGUI_Lib/app/tutorial/rgb_led/: Backend_RGBLED.c GUI_RGBLED_DIALOG.c
  group tutorial/musci_player
    ../../emXGUI_Lib/app/tutorial/music_player/: GUI_MUSICPLAYER_DIALOG.c WAV_Player.c
  group MP3
    ../../User/bsp/mp3/: mp3dec.c mp3tabs.c
    ../../User/bsp/mp3/real/: bitstream.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../User/bsp/mp3/real/arm/: asmpoly_thumb2.s asmmisc.s
  group tutorial/pic_viwer
    ../../emXGUI_Lib/app/tutorial/pic_view/: GUI_PicViwer_Dialog.c
  group tutorial/video_player
    ../../emXGUI_Lib/app/tutorial/video_player/: Backend_avifile.c Backend_vidoplayer.c GUI_VEDIOPLAYER_DIALOG.c
  group tutorial/camera
    ../../emXGUI_Lib/app/tutorial/camera/: GUI_CAMERA_DIALOG.c
    ../../User/bsp/camera/: bsp_ov5640.c ov5640_AF.c
